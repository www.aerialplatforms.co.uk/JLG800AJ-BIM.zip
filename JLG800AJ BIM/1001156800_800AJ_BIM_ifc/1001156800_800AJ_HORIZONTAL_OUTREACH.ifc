Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-03-20T15:12:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 20 15:12:56 2018 * Host: CHTSP10141 * Database: C:\Users\20062089\AppData\Local\Temp\{96240086-6098-4B89-A9F0-4477DDCA61CF}\ifc * Database version: 5507 * Database creation date: Tue Mar 20 15:12:50 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 20 15:12:50 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 20 15:12:50 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcTransportElement: Height=9.00m(29'-6")_Reach=15.35m(50'-4"), 1001156800_800AJ:Height=9.00m(29'-6")_Reach=15.35m(50'-4"):937047
In: Level 1
Type - PredefinedType: ELEVATOR; Material: button r, button g, cover metal(1), button 1, JLG_Metal Paint_White, JLG_Metal Paint_Black, JLG_Paint_Orange, JLG_Paint_Beige, JLG_Rubber_Black, JLG_Plastic_Dark Grey, JLG_Steel, JLG_Paint_Black
Type - Constraints - A: 925 mm; Aa: 78 deg; AE: 5695 mm; AEa: 1.27 deg; Ja: 0 deg; Reach: 41
Type - Data - Axle Oscillation: 0.20 m (0 ft 8 in); Drive Speed 2WD: 4.8 kph (3 mph); Drive Speed 4WD: 4.8 kph (3 mph); Electrical system: 12V-DC; Engine options: Gasoline, diesel; Fuel Tank Capacity: 147.63L (39 gal); Gradeability 2WD: 30%; Gradeability 4WD: 45%; Ground Clearance: 0.28 m (0 ft 11 in); Horizontal Outreach: 15.80 m (51 ft 10 in); Hydraulic Tank Capacity: 151.42 L (40 gal); Jib – Overall Length: 1.83m ( 6 ft 0 in); Jib Range of Articulation: 130 Degrees (+70/-60); Machine weight (CE): 15,558 kg (34,300 lbs); Machine weight_4WS (ANSI): 15,333 kg (33,805 lbs); Machine weight 2WS (ANSI): 15,481kg (34,130 lbs); Max Ground Bearing Pressure (ANSI): 5.3 kg/cm2 (76 psi); Max Ground Bearing Pressure (CE): 5.4 kg/cm2 (76.81 psi); Model Name: 800AJ; Platform Capacity (ANSI): 227 kg (500 lbs); Platform Capacity (CE): 230kg (507 lbs); Platform Height: 24.38 m (80 ft 0 in); Platform Rotator: 180 Degrees; Platform Size: 0.91 x 1.83 m (3 ft 0 in x 6 ft 0 in); Swing: 360 Degrees Continuous; Turning Radius Inside 2WS: 3.80 m ( 12 ft 6 in); Turning Radius Inside-4WS: 1.83 m ( 6 ft 0 in); Turning Radius Outside 2WS: 6.02 m ( 19 ft 8 in); Turning Radius outside-4WS: 3.53 m ( 11 ft 7 in); Tyres-Foam filled: 18-625; Tyres -pneumatic: 15-625; Up and Over Height: 9.78 m (32 ft 1 in)
Type - Dimensions - Aa1: 258 deg; AEa1: 181.27 deg; AHa: 78 deg; AHa1: 258 deg; Ja1: 180 deg; JHa: -1.27 deg; JHa1: 178.73 deg; PHa: 0 deg; PHa1: 180 deg
Type - General - Articulating Jib: 1.83 m articulating jib; Hydraulic Platform Rotator: 180 degree Hydraulic platform rotator; Platform Side Entry: 0.91 m x 1.83 m low mount platform, Side entry with drop bar mid rail; Tilt Alarm/Indicator Light: 4 Degrees CE/AUS, 5 Degrees Japan
Type - Identity Data - Manufacturer: JLG; OmniClass Number: 23.40.00.00; OmniClass Title: Equipment and Furnishings; Type Name: Height=9.00m(29'-6")_Reach=15.35m(50'-4")
Type - Model Properties - _Author: n/a; _AuthorizedBy: n/a; _BIMspec_GUID: n/a; _BimSpecGuid: n/a; _BSBibleVersion: n/a; _CreatedBy: JLG; _CurrentRevision: 0; _DistributedBy: JLG; BIMObjectName: 1001156800_800AJ; NBSDescription: Articulating Boom Lift; NBSNote: n/a; NBSObjectName: JLG 800AJ_Articulating Boom Lift; NBSOfficeMasterTag: n/a; NBSReference: n/a
Type - Other - Category: Mechanical Equipment; AccessibilityPerformance: n/a; AssetIdentifier (default): Please Record On Commissioning; AssetType: Elevators; BarCode (default): Please Record On Commissioning; ClassificationName: n/a; ClassificationValue: n/a; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: JLG (https://www.jlg.com/en); CreatedOn: 2018; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: 1001156800_800AJ; Features: n/a; Finish: n/a; Grade: n/a; InstallationDate (default): n/a; ManufacturerName: JLG (https://www.jlg.com/en); Material: n/a; ModelNumber: 800AJ; ModelReference: JLG - Articulating Boom Lift; ProductionYear: n/a; ReferencedStandard: n/a; ReplacementCost: n/a; SerialNumber (default): Please Record On Commissioning; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.jlg.com; WarrantyGuarantorParts: https://www.jlg.com
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG - Articulating Boom Lift; Manufacturer: JLG; ProductionYear: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 989.596 m2; Platform Rotation: 0 deg; PR: 0 deg; Reach Diagram: no; Sa1: 180 deg; Swing_Angle: 0 deg; Turning Radius_2WS: no; Turning Radius_4WS: no; Volume: 12.1173 m3; Working Area: no
Identity Data - Mark: 40
Other - Family: 1001156800_800AJ: Height=9.00m(29'-6")_Reach=15.35m(50'-4"); Family and Type: 1001156800_800AJ: Height=9.00m(29'-6")_Reach=15.35m(50'-4"); Type: 1001156800_800AJ: Height=9.00m(29'-6")_Reach=15.35m(50'-4"); Type Id: 1001156800_800AJ: Height=9.00m(29'-6")_Reach=15.35m(50'-4"); WarrantyStartDate (default): Please Record On Commissioning
Phasing - Phase Created: Phase 1
